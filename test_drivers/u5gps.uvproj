# Keil uVision project u5gps.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: u5gps
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s u5gps.c LCD.c
    ../MCAL/UART5/: UART5.c UART5.h
    ../MCAL/STK/: Systick.c Systick.h
    ../MCAL/GPIO/: DIO_Driver.c DIO_Driver.h
    ../MCAL/UART0/: UART0_PC.c UART0_PC.h
    ../HAL/GPS/: GPS.c GPS.h
