# Keil uVision project main.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./MAIN/: main.c SAVE.c SAVE.h
    ./MCAL/GPIO/: DIO_Driver.c
    ./MCAL/EEPROM/: eeprom.c
    ./MCAL/STK/: Systick.c
    ./MCAL/UART0/: UART0_PC.c
    ./MCAL/UART5/: UART5.c
    ./HAL/GPS/: GPS.c
    ./HAL/LCD/: LCD.c
    ./HAL/LED/: LED.c
    ./HAL/SW/: SW.c ext_sw.c
    ./UTILITIES/: Conversion.c
    ./: startup_TM4C123.s
software components: CMSIS:CORE 5.6.0
